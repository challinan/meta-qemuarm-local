FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://change-destop-label.patch"
